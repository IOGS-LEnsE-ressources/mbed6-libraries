# Keil uVision project G431KB_Timer_TIM2.uvprojx, settings and files
target G431KB_Base (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G431KBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G431KB_Base +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: gpio.c adc.c i2c.c lptim.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c main_func.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_lptim.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Docs
    ../../: _readme.txt g431KB.png pinout_IOC_Cube.txt
  group Main
    ../Main/: main.c
software components: CMSIS:CORE 4.3.0
