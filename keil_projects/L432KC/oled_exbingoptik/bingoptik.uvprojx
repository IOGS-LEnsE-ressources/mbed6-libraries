# Keil uVision project bingoptik.uvprojx, settings and files
target bingoptik_L432KC (6220000::V6.22::ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: bingoptik_L432KC
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_M4 TARGET_CORTEX MBED_RAM_START=0x20000000 __MICROLIB MULADDC_CANNOT_USE_R7 DEVICE_CAN=1 DEVICE_STDIO_MESSAGES=1 TARGET_CORTEX_M MBED_RAM1_START=0x10000000 TOOLCHAIN_ARM TARGET_NAME=NUCLEO_L432KC DEVICE_PORTIN=1 ARM_MATH_CM4 TARGET_STM32L432xC DEVICE_PORTINOUT=1 TRANSACTION_QUEUE_SIZE_SPI=2 USE_HAL_DRIVER __FPU_PRESENT=1 TARGET_LIKE_CORTEX_M4 DEVICE_SPISLAVE=1 DEVICE_LPTICKER=1 TOOLCHAIN_ARM_STD DEVICE_I2C=1 TOOLCHAIN_ARMC6 DEVICE_ANALOGOUT=1 MBED_RAM_SIZE=0xc000 TARGET_NUCLEO_L432KC EXTRA_IDLE_STACK_REQUIRED __CMSIS_RTOS MBED_ROM_START=0x8000000 DEVICE_PORTOUT=1 DEVICE_I2CSLAVE=1 DEVICE_ANALOGIN=1 __MBED__=1 DEVICE_RESET_REASON=1 DEVICE_USTICKER=1 DEVICE_SERIAL=1 MBED_TRAP_ERRORS_ENABLED=1 __ASSERT_MSG DEVICE_SERIAL_FC=1 DEVICE_I2C_ASYNCH=1 TARGET_RTOS_M4_M7 TARGET_MCU_STM32L4 DEVICE_FLASH=1 STM32L432xx MBED_RAM1_SIZE=0x4000 DEVICE_PWMOUT=1 MBED_DEBUG MBED_TICKLESS __CORTEX_M4 DEVICE_WATCHDOG=1 DEVICE_MPU=1 TARGET_LIKE_MBED TARGET_STM32L4 __MBED_CMSIS_RTOS_CM DEVICE_SPI=1 TARGET_STM MBED_BUILD_TIMESTAMP=1748028951.2829187 DEVICE_SERIAL_ASYNCH=1 USE_FULL_LL_DRIVER MBED_ROM_SIZE=0x40000 DEVICE_SPI_ASYNCH=1 DEVICE_RTC=1 DEVICE_TRNG=1 TARGET_RELEASE DEVICE_INTERRUPTIN=1 TARGET_MCU_STM32L432xC MBED_MINIMAL_PRINTF DEVICE_CRC=1 TARGET_MCU_STM32 MBED_RTOS_SINGLE_THREAD DEVICE_SLEEP=1
  c misc: -Wno-armcc-pragma-anon-unions -c -mthumb -fno-exceptions -mcpu=cortex-m4 -fno-c++-static-destructors --target=arm-arm-none-eabi -Wno-reserved-user-defined-literal -mfloat-abi=hard -Wno-deprecated-register -fdata-sections -fno-rtti -fshort-wchar -mfpu=fpv4-sp-d16 -g -fshort-enums -Wno-armcc-pragma-push-pop -include mbed_config.h
  c include: .;libs;C:/Keil_v5/mbed-os;C:/Keil_v5/mbed-os/cmsis;C:/Keil_v5/mbed-os/cmsis/CMSIS_5;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;C:/Keil_v5/mbed-os/cmsis/device;C:/Keil_v5/mbed-os/cmsis/device/RTE;C:/Keil_v5/mbed-os/cmsis/device/RTE/include;C:/Keil_v5/mbed-os/cmsis/device/rtos;C:/Keil_v5/mbed-os/connectivity;C:/Keil_v5/mbed-os/connectivity/cellular;C:/Keil_v5/mbed-os/connectivity/drivers;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/cellular;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair/ALT1250;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GEMALTO;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GENERIC;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/M26;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/RiotMicro;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/RiotMicro/AT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/HE910;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/ME310;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/ME910;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/AT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/emac/TARGET_STM;C:/Keil_v5/mbed-os/connectivity/drivers/mbedtls/TARGET_STM;C:/Keil_v5/mbed-os/connectivity/drivers/nfc;C:/Keil_v5/mbed-os/connectivity/drivers/nfc/PN512;C:/Keil_v5/mbed-os/connectivity/drivers/wifi;C:/Keil_v5/mbed-os/connectivity/drivers/wifi/esp8266-driver;C:/Keil_v5/mbed-os/connectivity/libraries;C:/Keil_v5/mbed-os/connectivity/libraries/mbed-coap;C:/Keil_v5/mbed-os/connectivity/libraries/nanostack-libservice;C:/Keil_v5/mbed-os/connectivity/libraries/ppp;C:/Keil_v5/mbed-os/connectivity/lorawan;C:/Keil_v5/mbed-os/connectivity/lwipstack;C:/Keil_v5/mbed-os/connectivity/mbedtls;C:/Keil_v5/mbed-os/connectivity/nanostack;C:/Keil_v5/mbed-os/connectivity/netsocket;C:/Keil_v5/mbed-os/connectivity/nfc;C:/Keil_v5/mbed-os/drivers;C:/Keil_v5/mbed-os/drivers/device_key;C:/Keil_v5/mbed-os/drivers/include;C:/Keil_v5/mbed-os/drivers/include/drivers;C:/Keil_v5/mbed-os/drivers/include/drivers/interfaces;C:/Keil_v5/mbed-os/drivers/usb;C:/Keil_v5/mbed-os/events;C:/Keil_v5/mbed-os/features;C:/Keil_v5/mbed-os/features/frameworks;C:/Keil_v5/mbed-os/features/frameworks/greentea-client;C:/Keil_v5/mbed-os/features/frameworks/mbed-client-cli;C:/Keil_v5/mbed-os/features/frameworks/unity;C:/Keil_v5/mbed-os/features/frameworks/utest;C:/Keil_v5/mbed-os/hal;C:/Keil_v5/mbed-os/hal/include;C:/Keil_v5/mbed-os/hal/include/hal;C:/Keil_v5/mbed-os/hal/usb;C:/Keil_v5/mbed-os/hal/usb/include;C:/Keil_v5/mbed-os/hal/usb/include/usb;C:/Keil_v5/mbed-os/platform;C:/Keil_v5/mbed-os/platform/cxxsupport;C:/Keil_v5/mbed-os/platform/include;C:/Keil_v5/mbed-os/platform/include/platform;C:/Keil_v5/mbed-os/platform/include/platform/internal;C:/Keil_v5/mbed-os/platform/mbed-trace;C:/Keil_v5/mbed-os/platform/mbed-trace/include;C:/Keil_v5/mbed-os/platform/mbed-trace/include/mbed-trace;C:/Keil_v5/mbed-os/platform/randlib;C:/Keil_v5/mbed-os/platform/source;C:/Keil_v5/mbed-os/platform/source/minimal-printf;C:/Keil_v5/mbed-os/rtos;C:/Keil_v5/mbed-os/rtos/include;C:/Keil_v5/mbed-os/rtos/include/rtos;C:/Keil_v5/mbed-os/rtos/include/rtos/internal;C:/Keil_v5/mbed-os/rtos/source;C:/Keil_v5/mbed-os/storage;C:/Keil_v5/mbed-os/storage/blockdevice;C:/Keil_v5/mbed-os/storage/blockdevice/include;C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice;C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/internal;C:/Keil_v5/mbed-os/storage/filesystem;C:/Keil_v5/mbed-os/storage/kvstore;C:/Keil_v5/mbed-os/targets/TARGET_STM;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC;D:/tools/git_repo/digital_methods/keil_stm32/MBED_os/boards/L432KC/bingoptik_L432KC/mbed-os
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DARM_MATH_CM4,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DUSE_FULL_LL_DRIVER,-DMBED_TICKLESS,-D__CORTEX_M4,-DSTM32L432xx,-DUSE_HAL_DRIVER,-D__CMSIS_RTOS,-DEXTRA_IDLE_STACK_REQUIRED,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TOOLCHAIN_ARM/stm32l432xc.sct
  link misc: --predefine="-DMBED_RAM1_SIZE=0x4000" --legacyalign --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --keep=os_cb_sections --remove --predefine="-DMBED_RAM_SIZE=0xc000" --library_type=microlib --predefine="-DXIP_ENABLE=0" --verbose --show_full_path --cpu=Cortex-M4 --predefine="-DMBED_ROM_SIZE=0x40000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DMBED_RAM1_START=0x10000000" --any_contingency
  group bingoptik_L432KC
    ./: main.cpp
    ./: mbed_config.h
  group libs
    ./libs/: font.cpp font.h LCD_graphics.cpp LCD_graphics.h ssd1306.cpp ssd1306.h ssd1306_constants.h PixelArray.cpp PixelArray.h WS2812.cpp WS2812.h
    ./: bingo_strips.h bingo_strips.cpp
  group mbed-os
    C:/Keil_v5/mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BufferedSerial.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp MbedCRC.cpp OSPI.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp ResetReason.cpp SerialBase.cpp SerialWireOutput.cpp SPI.cpp SPISlave.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UnbufferedSerial.cpp Watchdog.cpp
    C:/Keil_v5/mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h OSPI.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawCAN.h RealTimeClock.h ResetReason.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h UnbufferedSerial.h Watchdog.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c lp_ticker_defines.h mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h ospi_api.c PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c qspi_api.c reset_reason.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker.c us_ticker_defines.h USBPhy_STM32.cpp USBPhyHw.h watchdog_api.c
    C:/Keil_v5/mbed-os/hal/include/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h ospi_api.h pinmap.h PinNameAliases.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/: analogin_device.c analogout_device.c can_device.h cmsis.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.c i2c_device.h objects.h PeripheralNames.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h us_ticker_data.h
    C:/Keil_v5/mbed-os/platform/source/: ATCmdParser.cpp CriticalSectionLock.cpp CThunkBase.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_mpu_mgmt.c mbed_os_timer.cpp mbed_poll.cpp mbed_power_mgmt.c mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_thread.cpp mbed_wait_api_no_rtos.c Stream.cpp SysTimer.cpp
    C:/Keil_v5/mbed-os/platform/include/platform/: ATCmdParser.h Callback.h CircularBuffer.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h
    C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    C:/Keil_v5/mbed-os/storage/blockdevice/source/: BufferedBlockDevice.cpp ChainingBlockDevice.cpp ExhaustibleBlockDevice.cpp FlashSimBlockDevice.cpp HeapBlockDevice.cpp MBRBlockDevice.cpp ObservingBlockDevice.cpp ProfilingBlockDevice.cpp ReadOnlyBlockDevice.cpp SFDP.cpp SlicingBlockDevice.cpp
    C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/: cmsis_nvic.h system_clock.c
    C:/Keil_v5/mbed-os/rtos/source/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp rtos_handlers.h rtos_idle.h Semaphore.cpp ThisThread.cpp Thread.cpp
    C:/Keil_v5/mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h mbed_rtos_types.h MemoryPool.h Mutex.h Queue.h rtos.h Semaphore.h ThisThread.h Thread.h
    C:/Keil_v5/mbed-os/platform/include/platform/internal/: CThunkBase.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h SysTimer.h
    C:/Keil_v5/mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    C:/Keil_v5/mbed-os/drivers/include/drivers/interfaces/: InterfaceCAN.h InterfaceDigitalIn.h InterfaceDigitalInOut.h InterfaceDigitalOut.h
    C:/Keil_v5/mbed-os/hal/source/: LowPowerTickerWrapper.cpp mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_pinmap_default.cpp mbed_ticker_api.c mbed_us_ticker_api.c static_pinmap.cpp
    C:/Keil_v5/mbed-os/: mbed.h
    C:/Keil_v5/mbed-os/cmsis/device/: mbed_cmsis_conf.h
    C:/Keil_v5/mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c
    C:/Keil_v5/mbed-os/features/frameworks/mbed-greentea-io/: mbed_io.cpp
    C:/Keil_v5/mbed-os/hal/source/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    C:/Keil_v5/mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_implementation.h mbed_printf_wrapper.c
    C:/Keil_v5/mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    C:/Keil_v5/mbed-os/platform/mbed-trace/source/: mbed_trace.c
    C:/Keil_v5/mbed-os/platform/mbed-trace/include/mbed-trace/: mbed_trace.h ns_trace.h
    C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.c
    C:/Keil_v5/mbed-os/hal/usb/source/: mbed_usb_phy.cpp
    C:/Keil_v5/mbed-os/platform/cxxsupport/: mstd_mutex.cpp
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC/: PeripheralPins.c PinNames.h
    C:/Keil_v5/mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/internal/: SFDP.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TOOLCHAIN_ARM/: startup_stm32l432xx.S
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy/: stm32_hal_legacy.h stm32l4xx_hal_can_legacy.c stm32l4xx_hal_can_legacy.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS/: stm32l412xx.h stm32l422xx.h stm32l431xx.h stm32l432xx.h stm32l433xx.h stm32l442xx.h stm32l443xx.h stm32l451xx.h stm32l452xx.h stm32l462xx.h stm32l471xx.h stm32l475xx.h stm32l476xx.h stm32l485xx.h stm32l486xx.h stm32l496xx.h stm32l4a6xx.h stm32l4p5xx.h stm32l4q5xx.h stm32l4r5xx.h stm32l4r7xx.h stm32l4r9xx.h stm32l4s5xx.h stm32l4s7xx.h stm32l4s9xx.h stm32l4xx.h system_stm32l4xx.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/: stm32l4xx_hal.c stm32l4xx_hal.h stm32l4xx_hal_adc.c stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.c stm32l4xx_hal_can.h stm32l4xx_hal_comp.c stm32l4xx_hal_comp.h stm32l4xx_hal_cortex.c stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.c stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.c stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.c stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.c stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dsi.c stm32l4xx_hal_dsi.h stm32l4xx_hal_exti.c stm32l4xx_hal_exti.h stm32l4xx_hal_firewall.c stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.c stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.c stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.c stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.c stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.c stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.c stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.c stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc.h stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_mmc_ex.h stm32l4xx_hal_nand.c stm32l4xx_hal_nand.h stm32l4xx_hal_nor.c stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.c stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pka.c stm32l4xx_hal_pka.h stm32l4xx_hal_pssi.c stm32l4xx_hal_pssi.h stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.c stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.c stm32l4xx_hal_rng.h stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rng_ex.h stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.c stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.c stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus.h stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_smbus_ex.h stm32l4xx_hal_spi.c stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.c stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.c stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.c stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.c stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.c stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.c stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.c stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.c stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_crs.c stm32l4xx_ll_crs.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_dma.c stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.c stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.c stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.c stm32l4xx_ll_opamp.h stm32l4xx_ll_pka.c stm32l4xx_ll_pka.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.c stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.c stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.c stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_usb.c stm32l4xx_ll_usb.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/: stm32l4xx_hal_conf.h system_stm32l4xx.c
    C:/Keil_v5/mbed-os/hal/usb/include/usb/: usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
